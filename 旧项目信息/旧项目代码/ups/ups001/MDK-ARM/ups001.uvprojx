# Keil uVision project ups001.uvprojx, settings and files
target ups001 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ups001 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./App;./Int;./FreeRTOS/include;./Com;./FreeRTOS/portable/RVDS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./App/: App_Display.c App_Main.c App_BatMan.c App_UpsMan.c App_Soc.c
  group Int
    ./Int/: Int_BQ769.c Int_Can.c Int_OLED.c
  group FreeRTOS
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/: port.c
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Com
    ./Com/: Com_Bq769.c
software components: CMSIS:CORE 5.6.0
