# Keil uVision project bms24v_platform.uvprojx, settings and files
target bms24v_platform (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G0B1CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: bms24v_platform +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G0B1xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;FreeRTOS/include;FreeRTOS/portable/RVDS/ARM_CM0;Int;../../App;../../Com;../../Int
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Application/MDK-ARM
    ./: startup_stm32g0b1xx.s
  group Application/User/Core
    ../Core/Src/: retarget.c main.c gpio.c fdcan.c i2c.c rtc.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c
  group Application/User/App
    ../../App/: App_Main.c App_Main.h App_DebugCli.c App_DebugCli.h App_BatMan.c App_BatMan_Config.c App_BatMan_Sample.c App_BatMan_Estimator.c App_BatMan_Debug.c App_BatMan.h App_BatMan_Internal.h App_OLED.c App_OLED.h App_Power.c App_Power.h App_SC8815.c App_SC8815.h
  group Application/User/Com
    ../../Com/: Com_BQ76952.c Com_BQ76952.h Com_BatteryParam.c Com_BatteryParam.h Com_SOC.c Com_SOC.h Com_SOH.c Com_SOH.h
  group Application/User/Int
    ../../Int/: Int_BQ76952.c Int_BQ76952.h Int_BQ76952_BSP.h Int_OLED.c Int_OLED.h Int_font.h Int_SC8815.c Int_SC8815.h Int_SC8815_BSP.h Int_CanFd.c Int_CanFd.h Int_Led.c Int_Led.h Int_EEPROM.c Int_EEPROM.h
  group Middle/FreeRTOS
    FreeRTOS/source/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    FreeRTOS/portable/MemMang/: heap_4.c
    FreeRTOS/include/: FreeRTOSConfig.h
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
software components: CMSIS:CORE 4.3.0
